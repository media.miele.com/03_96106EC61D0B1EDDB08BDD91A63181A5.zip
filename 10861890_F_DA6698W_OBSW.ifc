Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T10:18:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 10:18:44 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3c901732-16e2-44d7-9e47-e913819eff5e\ec62a815-4296-42f3-a763-5802a2b3f406\ifc * Database version: 5507 * Database creation date: Tue Mar 07 10:18:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 10:18:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 10:18:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10861890_F_DA6698W_OBSW:28669840_F_10861890_DA6698W_OBSW, (2)
In: Default
Type - Classification: WAND-DEKOR DA (Uniformat); Material: z_Miele_Design_Glass
Type - Pset_BuildingElementProxyCommon - Reference: 28669840_F_10861890_DA6698W_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28669840_F_10861890_DA6698W_OBSW
Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 898 mm; Height: 85 mm; Depth: 500 mm
